v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 310 -140 0 0 {name=p24 sig_type=std_logic lab=data}
C {lab_pin.sym} 430 -160 2 0 {name=p4 sig_type=std_logic lab=B_out}
C {lab_pin.sym} 310 -180 0 0 {name=p19 sig_type=std_logic lab=clki}
C {ipin.sym} 130 -300 0 0 {name=p1 lab=data}
C {opin.sym} 130 -260 0 0 {name=p12 lab=B_out}
C {iopin.sym} 130 -240 0 0 {name=p59 lab=vdd}
C {iopin.sym} 130 -220 0 0 {name=p60 lab=vss}
C {ipin.sym} 130 -320 0 0 {name=p13 lab=clki}
C {sky130_stdcells/nand2_4.sym} 370 -160 0 0 {name=x1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
