v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} 120 -280 0 0 {name=p1 lab=clk}
C {ipin.sym} 120 -260 0 0 {name=p2 lab=rst_n}
C {iopin.sym} 120 -240 0 0 {name=p3 lab=ua[0:7]}
C {ipin.sym} 120 -220 0 0 {name=p4 lab=ui_in[0:7]}
C {iopin.sym} 120 -200 0 0 {name=p5 lab=uio_in[0:7]}
C {iopin.sym} 120 -180 0 0 {name=p6 lab=uio_oe[0:7]}
C {iopin.sym} 120 -160 0 0 {name=p7 lab=uio_out[0:7]}
C {opin.sym} 120 -140 0 0 {name=p8 lab=uo_out[0:7]}
C {iopin.sym} 120 -120 0 0 {name=p9 lab=VDPWR}
C {iopin.sym} 120 -100 0 0 {name=p10 lab=VGND}
