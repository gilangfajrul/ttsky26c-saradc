v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 320 -200 2 0 {name=p52 sig_type=std_logic lab=A_out}
C {lab_pin.sym} 200 -180 0 0 {name=p69 sig_type=std_logic lab=data}
C {lab_pin.sym} 200 -220 0 0 {name=p17 sig_type=std_logic lab=clki}
C {ipin.sym} 100 -360 0 0 {name=p1 lab=data}
C {opin.sym} 100 -340 0 0 {name=p11 lab=A_out}
C {iopin.sym} 100 -300 0 0 {name=p59 lab=vdd}
C {iopin.sym} 100 -280 0 0 {name=p60 lab=vss}
C {ipin.sym} 100 -380 0 0 {name=p13 lab=clki}
C {sky130_stdcells/and2b_4.sym} 260 -200 2 1 {name=x1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
