v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {sar-adc.sym} 610 -260 0 0 {name=x1}
C {iopin.sym} 180 -270 0 0 {name=p59 lab=VDPWR}
C {iopin.sym} 180 -250 0 0 {name=p60 lab=VGND}
C {ipin.sym} 180 -390 0 0 {name=p55 lab=ui_in[0:7]}
C {ipin.sym} 180 -370 0 0 {name=p56 lab=uio_in[0:7]}
C {opin.sym} 180 -330 0 0 {name=p1 lab=uo_out[7:0]}
C {ipin.sym} 180 -450 0 0 {name=p4 lab=clk}
C {ipin.sym} 180 -430 0 0 {name=p5 lab=rst_n}
C {iopin.sym} 180 -410 0 0 {name=p3 lab=ua[0:7]}
C {lab_pin.sym} 630 -330 0 0 {name=p7 sig_type=std_logic lab=VDPWR}
C {lab_pin.sym} 630 -190 0 0 {name=p8 sig_type=std_logic lab=VGND}
C {lab_pin.sym} 460 -280 0 0 {name=p9 sig_type=std_logic lab=ua[1]}
C {lab_pin.sym} 460 -240 0 0 {name=p10 sig_type=std_logic lab=ua[0]}
C {lab_pin.sym} 460 -220 0 0 {name=p11 sig_type=std_logic lab=clk}
C {lab_pin.sym} 760 -260 2 0 {name=p12 sig_type=std_logic lab=uo_out[7:0]}
C {lab_pin.sym} 760 -220 2 0 {name=p13 sig_type=std_logic lab=uio_out[0]}
C {opin.sym} 180 -350 0 0 {name=p2 lab=uio_out[0]}
